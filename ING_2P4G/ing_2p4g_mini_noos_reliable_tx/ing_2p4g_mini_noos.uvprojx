# Keil uVision project ing_2p4g_mini_noos.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: ing_2p4g_mini_noos +hex
  AfterMake: fromelf.exe --bin -o ing_2p4g_mini_noos.bin ./output/ing_2p4g_mini_noos.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\2P4G_lib;../../../../sdk/bundles/noos_mini/inc;../../../../sdk/bundles/noos_mini/inc/os;../../../../sdk/src/BSP;../../../../sdk/src/FWlib;../../../../sdk/src/StartUP/ing916;../../../../sdk/src/Tools;../../../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2027000 size 0x59000
  memory RVCT9: RAM 0x20004400 size 0x9c00
  group APP
    ./src/: main.c profile.c my_irq.c noos_impl.c uart_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: eflash.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../sdk/src/Tools/: trace.c
  group 2G4P
    ../2P4G_lib/: BLE_2P4G_Switch.lib
    ./src/: app_24g.c ing_24g.c
software components: CMSIS:CORE 4.3.0
