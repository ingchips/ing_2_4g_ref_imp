# Keil uVision project BLE_2P4G_Switch.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: BLE_2P4G_Switch +hex
  AfterMake: fromelf.exe --bin -o BLE_2P4G_Switch.bin ./output/BLE_2P4G_Switch.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,
  c include: ./2P4G/;../../bundles/extension/inc;../../bundles/extension/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src;./2P4G/registers
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20005450 size 0x2bb0
  group APP
    ./src/: main.c profile.c TEST_2P4G.c uart_console.c
  group StartUP
    ../../bundles/extension/ING9168xx/: symdefs.m
    ./src/: startup_ing91600.s
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../src/Tools/: trace.c
  group 2P4G
    ./2P4G/: BLE_2P4G_Switch.lib
software components: CMSIS:CORE 4.3.0
