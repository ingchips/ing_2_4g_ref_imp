# Keil uVision project ing_2g4p_switch_mini.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: ing_2g4p_switch_mini +hex
  AfterMake: fromelf.exe --bin -o ing_2g4p_switch_mini.bin ./output/ing_2g4p_switch_mini.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/mini/inc;sdk/bundles/mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src;.\src;..\..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20007228 size 0x6dd8
  group APP
    ./src/: main.c profile.c my_irq.c TEST_2P4G.c
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/mini/ING9168xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
  group 2G4P
    ../../lib/: BLE_2P4G_Switch.lib
software components: CMSIS:CORE 4.3.0
