# Keil uVision project ING_BLE_2P4G_example.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: ING_BLE_2P4G_example +hex
  AfterMake: fromelf.exe --bin -o ING_BLE_2P4G_example.bin ./output/ING_BLE_2P4G_example.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../sdk/bundles/extension/inc;../sdk/bundles/extension/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src;.\src;..\..\lib;../../../../Program Files/ING_SDK/sdk/bundles/extension/inc;../../../../Program Files/ING_SDK/sdk/bundles/extension/inc/os;../../../../Program Files/ING_SDK/sdk/src/BSP;../../../../Program Files/ING_SDK/sdk/src/FWlib;../../../../Program Files/ING_SDK/sdk/src/StartUP/ing916;../../../../Program Files/ING_SDK/sdk/src/Tools;../../../../Program Files/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x202b000 size 0x55000
  memory RVCT9: RAM 0x20005410 size 0x2bf0
  group APP
    ./src/: main.c profile.c my_irq.c TEST_2P4G.c uart_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/extension/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: eflash.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../sdk/src/Tools/: trace.c
  group 2P4G
    ../../lib/: BLE_2P4G_Switch.lib
software components: CMSIS:CORE 4.3.0
